# Keil uVision project Keil_LPC11U37.uvproj, settings and files
target Keil_LPC11U37 (ARM-ADS)
  device: LPC11U37/401 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10001FFF) IRAM2(0x20004000-0x200047FF) IROM(0-0x1FFFF) CLOCK(12000000) CPUTYPE("Cortex-M0")
  output: Keil_LPC11U37
  c flags: Optim=1 OneElfS=1
  c define: CFG_BRD_RF1GHZNODE
  c misc: --gnu --c99
  c include: ./cmsis;src;src/cli
  asm include: ./cmsis;src;src/cli
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x10000000 size 0x2000
  memory RVCT10: RAM 0x20004000 size 0x800
  group cmsis
    ./cmsis/: system_LPC11Uxx.c startup_LPC11Uxx_arm.s
  group src
    ./src/: printf-retarget.c projectconfig.h
  group boards
    ./src/boards/rf1ghznode/: RTX_Conf_CM.c board_rf1ghznode.c
    ./src/boards/lpcxpresso1347/: board_lpcxpresso1347.c
    ./src/boards/rf1ghzusb/: board_rf1ghzusb.c
    ./src/boards/lpcnfc/: board_lpcnfc.c
  group cli
    ./src/cli/: commands.c cli.c
    ./src/cli/commands/: cmd_chibi_addr.c cmd_chibi_tx.c cmd_dbg_memrd.c cmd_eeprom_read.c cmd_eeprom_write.c cmd_i2c_read.c cmd_i2c_scan.c cmd_i2c_write.c cmd_nfc_mfc_ndef.c cmd_nfc_mifareclassic_memdump.c cmd_nfc_mifareclassic_valueblock.c cmd_nfc_mifareultralight_memdump.c cmd_rtc_read.c cmd_rtc_write.c cmd_sd_dir.c cmd_sysinfo.c
  group core
    ./src/core/uart/: uart_buf.c uart.c
    ./src/core/timer32/: timer32.c
    ./src/core/delay/: delay.c
    ./src/core/ssp1/: ssp1.c
    ./src/core/ssp0/: ssp0.c
    ./src/core/pmu/: pmu.c
    ./src/core/iap/: iap.c
    ./src/core/i2c/: i2c.c
    ./src/core/gpio/: gpio.c
    ./src/core/fifo/: fifo.c
    ./src/core/eeprom/: eeprom.c
    ./src/core/adc/: adc.c
  group core_usb
    ./src/core/usb/: descriptors.c usb_cdc.c usb_hid.c usb_msc.c usbd.c
  group drivers_timespan
    ./src/drivers/: timespan.c
  group bitbanging_swspi
    ./src/drivers/bitbanging/swspi/: swspi.c
  group displays
    ./src/drivers/displays/: smallfonts.c
  group displays_bitmap_ssd1306
    ./src/drivers/displays/bitmap/ssd1306/: ssd1306_i2c.c
  group displays_graphic
    ./src/drivers/displays/graphic/: aafonts.c colors.c drawing.c fonts.c theme.c
  group displays_graphic_aafonts_aa2
    ./src/drivers/displays/graphic/aafonts/aa2/: DejaVuSansCondensed14_AA2.c DejaVuSansCondensedBold14_AA2.c DejaVuSansMono10_AA2.c DejaVuSansMono13_AA2.c DejaVuSansMono14_AA2.c FontCalibri18_AA2.c FontCalibriBold18_AA2.c FontCalibriItalic18_AA2.c FontFranklinGothicBold99_Numbers_AA2.c
  group displays_graphic_aafonts_aa4
    ./src/drivers/displays/graphic/aafonts/aa4/: FontCalibri18_AA4.c
  group displays_graphic_fonts
    ./src/drivers/displays/graphic/fonts/: dejavusans9.c dejavusansbold9.c dejavusanscondensed9.c dejavusansmono8.c dejavusansmonobold8.c veramono11.c veramono9.c veramonobold11.c veramonobold9.c verdana14.c verdana9.c verdanabold14.c
  group displays_graphic_hw
    ./src/drivers/displays/graphic/hw/: hx8340b.c hx8347g.c
  group displays_segment_ht16k33
    ./src/drivers/displays/segment/ht16k33/: ht16k33.c
  group motor_stepper
    ./src/drivers/motor/stepper/: stepper.c
  group pwm_pca9685
    ./src/drivers/pwm/pca9685/: pca9685.c
  group rf_chibi
    ./src/drivers/rf/chibi/: chb.c chb_buf.c chb_drvr.c chb_eeprom.c chb_spi.c messages.c
  group rf_pn532
    ./src/drivers/rf/pn532/: pn532.c pn532_bus_i2c.c pn532_bus_uart.c
    ./src/drivers/rf/pn532/mem_allocator/: pn532_mem.c bget.c
    ./src/drivers/rf/pn532/helpers/: pn532_config.c pn532_gpio.c pn532_mifare_classic.c pn532_mifare_ultralight.c pn532_ndef.c pn532_ndef_cards.c
  group rtc
    ./src/drivers/rtc/: rtc.c
    ./src/drivers/rtc/pcf2129/: pcf2129.c
  group sensors
    ./src/drivers/sensors/: sensors.c
  group sensors_accelerometers
    ./src/drivers/sensors/accelerometers/: adxl345.c lis3dh.c lsm303accel.c
  group sensors_gyroscopes
    ./src/drivers/sensors/gyroscopes/: l3gd20.c
  group sensors_light
    ./src/drivers/sensors/light/: tsl2561.c
  group sensors_magnetometers
    ./src/drivers/sensors/magnetometers/: lsm303mag.c
  group sensors_pressure
    ./src/drivers/sensors/pressure/: bmp085.c mpl115a2.c
  group sensors_temperature
    ./src/drivers/sensors/temperature/: lm75b.c
  group drivers_filters
    ./src/drivers/filters/: avg_d.c avg_f.c avg_i.c iir_f.c
  group storage_fatfs
    ./src/drivers/storage/fatfs/: ff.c mmc.c
  group localisation
    ./src/localisation/: localisation.c
  group RTXlib
    ./cmsis/libs/: RTX_CM0.lib
